# Keil uVision project main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F042F6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group src
    ./: main.cpp usb_reader_core.c spi.cpp
    ./usb_dev/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_keyb_usr.c usbd_pwr.c usbd_req.c
    ../: aes.cpp MFRC522.cpp
  group header
    ./: usb_reader_core.h sha256.h
    ./usb_dev/: usb_bsp.h usb_conf.h usb_core.h usb_dcd.h usb_dcd_int.h usb_regs.h usbd_conf.h usbd_core.h usbd_def.h usbd_desc.h usbd_ioreq.h usbd_keyb_usr.h usbd_pwr.h usbd_req.h
    ../: spi.hpp MFRC522.hpp aes.hpp
software components: CMSIS:CORE 4.2.0, Device:Startup 1.5.0
