# Keil uVision project f030.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: f030
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./: main.cpp ow.cpp spi.cpp weigand.cpp
    ../: MFRC522.cpp aes.cpp
  group header
    ./: weigand.hpp ow.hpp
    ../: MFRC522.hpp spi.hpp aes.hpp
software components: CMSIS:CORE 4.2.0, Device:Startup 1.5.0
